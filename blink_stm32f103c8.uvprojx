# Keil uVision project blink_stm32f103c8.uvprojx, settings and files
target Blink (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: blink_stm32f103c8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\User\inc;.\Drivers;.\CMSIS;.\QPC\platform\inc;.\QPC\port\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group user\src
    ./User/src/: main.c bsp.c blink.c
  group drivers
    ./Drivers/: startup_stm32f10x_md.s
  group qpc
    ./QPC/platform/src/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c qxk.c qxk_mutex.c qxk_sema.c qxk_xthr.c
    ./QPC/port/src/: qxk_port.c
  group qspy
    ./QPC/spy/src/: qs.c qs_64bit.c qs_fp.c qs_rx.c qstamp.c
target Blink_with_QSpy (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: blink_stm32f103c8 +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: Q_SPY
  c include: .\User\inc;.\Drivers;.\CMSIS;.\QPC\platform\inc;.\QPC\port\inc;.\QPC\spy\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
